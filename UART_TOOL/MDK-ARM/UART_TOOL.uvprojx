# Keil uVision project UART_TOOL.uvprojx, settings and files
target UART_TOOL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: UART_TOOL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Drivers/CMSIS/Include;    ..\b_tp;    ..\platform;    ..\Drivers\uart;    ..\Drivers\spiflash;    ..\protocol;    ../Middlewares/Third_Party/FatFs/src;  ../Middlewares/Third_Party/LibJPEG/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c user_diskio.c fatfs.c libjpeg.c jdata_conf.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group b_tp/src
    ../b_tp/src/: b_tp.c
    ../b_tp/check/crc16/: crc16.c
    ../b_tp/b_tp_port/: b_tp_port.c
  group b_tp/inc
    ../b_tp/inc/: b_tp.h
    ../b_tp/check/crc16/: crc16.h
    ../b_tp/b_tp_port/: b_tp_config.h b_tp_port.h
  group protocol
    ../protocol/: protocol.c
  group platform
    ../platform/: heap_4.c
  group Driver/uart
    ../Drivers/uart/: uart.c
  group Driver/spiflash
    ../Drivers/spiflash/: flash_drv.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/LibJPEG
    ../Middlewares/Third_Party/LibJPEG/source/: jcapimin.c jcapistd.c jdapimin.c jdapistd.c jcomapi.c jcparam.c jctrans.c jdtrans.c jcinit.c jcmaster.c jcmainct.c jcprepct.c jccoefct.c jccolor.c jcsample.c jcdctmgr.c jfdctint.c jfdctfst.c jfdctflt.c jchuff.c jcarith.c jcmarker.c jdatadst.c jdmaster.c jdinput.c jdmainct.c jdcoefct.c jdpostct.c jdmarker.c jdhuff.c jdarith.c jddctmgr.c jidctint.c jidctfst.c jidctflt.c jdsample.c jdcolor.c jdmerge.c jquant1.c jquant2.c jdatasrc.c jaricom.c jerror.c jmemmgr.c jutils.c jmemnobs.c
software components: CMSIS:CORE 4.3.0
